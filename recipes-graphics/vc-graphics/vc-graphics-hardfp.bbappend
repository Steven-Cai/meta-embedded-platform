# INHIBIT_PACKAGE_STRIP = "1"

DEPENDS = "virtual/${TARGET_PREFIX}binutils gcc-runtime"

RDEPENDS_${PN} += "bash"