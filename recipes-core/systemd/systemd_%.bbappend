PACKAGECONFIG_append = " networkd resolved"

RDEPENDS_${PN}_append = " wpa-supplicant "

# PACKAGECONFIG_remove = "list of packages to remove"